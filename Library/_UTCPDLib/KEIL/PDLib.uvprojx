# Keil uVision project PDLib.uvprojx, settings and files
target PD_SNK (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: PD_SNK (library)
  AfterMake: cmd.exe /C copy /Y  .\obj\@L.lib  .\..\..\PowerDeliveryLib\@L.lib
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 wLevel=1
  c define: OPT_SNK_ONLY=1, OPT_SRC_ONLY=0, CONFIG_HOSTCMD_ALIGNED CONFIG_USB_PD_TCPC_RUNTIME_CONFIG  CHROMIUM_EC=1 CONFIG_USB_PD_FRS_TCPC=1  CONFIG_USB_PD_REV30=1 CONFIG_TC8260_FRS=1
  c include: ..\..\Device\Nuvoton\M55M1\Include;..\..\CMSIS\Core\Include;..\..\StdDriver\inc;..\..\PowerDeliveryLib\Include;..\..\PowerDeliveryLib\Include\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scatter
  group User
    ../: nct38xx.c usb_callback.c tcpci.c usb_sm.c ec_timer.c usb_pd_timer.c usb_prl_sm.c i2c_controller.c usb_pd_alt_mode_dfp.c usb_common.c dp_alt_mode.c usb_tc_drp_acc_trysrc_sm.c usb_pd_flags.c usbc_task.c usb_pd_dpm.c task_event.c usb_pd_dual_role.c
  group Porting
    ../: hwtimer.c
target PD_SRC (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: PD_SRC (library)
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 wLevel=1
  c define: OPT_SRC_ONLY=1, OPT_SNK_ONLY=0, CONFIG_HOSTCMD_ALIGNED CONFIG_USB_PD_TCPC_RUNTIME_CONFIG  CHROMIUM_EC=1 CONFIG_USB_PD_FRS_TCPC=1  CONFIG_USB_PD_REV30=1 CONFIG_TC8260_FRS=1
  c include: ..\..\Device\Nuvoton\M55M1\Include;..\..\CMSIS\Core\Include;..\..\StdDriver\inc;..\..\PowerDeliveryLib\Include\Inc;..\..\PowerDeliveryLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
target PD_DRP (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: PD_DRP (library)
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: OPT_DRP=1, CONFIG_HOSTCMD_ALIGNED CONFIG_USB_PD_TCPC_RUNTIME_CONFIG  CHROMIUM_EC=1 CONFIG_USB_PD_FRS_TCPC=1  CONFIG_USB_PD_REV30=1 CONFIG_TC8260_FRS=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
