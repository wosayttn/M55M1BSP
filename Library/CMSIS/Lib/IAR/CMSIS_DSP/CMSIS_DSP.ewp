# IAR project CMSIS_DSP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 61
  General.FPU2: 7
  ICCARM.CCDefines: ARM_MATH_DSP; ARM_MATH_LOOPUNROLL; ARM_MATH_HELIUM
  ICCARM.CCIncludePath2: ..\..\..\..\DSP\Include; ..\..\..\..\DSP\PrivateInclude; ..\..\..\..\Core\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: CMSIS-DSP.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BasicMathFunctions
    ../../../DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group BayesFunctions
    ../../../DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group CommonTables
    ../../../DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group ComplexMathFunctions
    ../../../DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group ControllerFunctions
    ../../../DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group DistanceFunctions
    ../../../DSP/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
  group FastMathFunctions
    ../../../DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group FilteringFunctions
    ../../../DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group InterpolationFunctions
    ../../../DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group MatrixFunctions
    ../../../DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group QuaternionMathFunctions
    ../../../DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group StatisticsFunctions
    ../../../DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group SupportFunctions
    ../../../DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group SVMFunctions
    ../../../DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group TransformFunctions
    ../../../DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
