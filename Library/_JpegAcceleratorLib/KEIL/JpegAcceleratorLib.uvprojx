# Keil uVision project JpegAcceleratorLib.uvprojx, settings and files
target JpegAcceleratorLib (6160000::V6.16::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: JpegAcceleratorLib (library)
  AfterMake: cmd.exe /C copy /Y Objects\JpegAcceleratorLib.lib ..\JpegAcceleratorLib_Keil.lib
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\..\..\Library\CMSIS\Core\Include;..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\Library\StdDriver\inc;..\..\JpegAcceleratorLib\include;..\..\..\ThirdParty\libjpeg
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\Device\Nuvoton\M55M1\Source\ARM\M55M1.scatter
  group Source
    ../Source/: jfdctint-helium.c jquanti-helium.c nvt_jpeg.c
