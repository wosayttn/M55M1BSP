# IAR project SmartCardLib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 61
  General.FPU2: 7
  ICCARM.IExtraOptions: --diag_suppress Pe550; --diag_suppress Pe177
  ICCARM.CCIncludePath2: ..\..\CMSIS\Core\Include; ..\..\Device\Nuvoton\M55M1\Include; ..\..\StdDriver\inc; ..\..\SmartcardLib\include; ..\Source
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: tflu.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Source
    ../Source/: sclib_api.c sclib_t0protocol.c sclib_t1protocol.c sclib_util.c
