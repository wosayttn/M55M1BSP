# Keil uVision project edgeimpulse_tflite_micro.uvprojx, settings and files
target Release (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: eitflu (library)
  AfterMake: xcopy /Y .\Objects\eitflu.lib ..\
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: FLATBUFFERS_LOCALE_INDEPENDENT=0, TF_LITE_STATIC_MEMORY, NDEBUG, EI_ETHOS=1
  c include: ..\..\edge-impulse-sdk;..\..\edge-impulse-sdk\tensorflow\lite\core\api;..\..\..\edgeimpulse_tflite_micro;..\..\..\..\Library\EthosULib\include
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group c
    ../../edge-impulse-sdk/tensorflow/lite/c/: common.c
  group core-api
    ../../edge-impulse-sdk/tensorflow/lite/core/api/: error_reporter.cpp flatbuffer_conversions.cpp op_resolver.cpp tensor_utils.cpp
  group kernels
    ../../edge-impulse-sdk/tensorflow/lite/kernels/: kernel_util_lite.cpp
  group kernels-internal
    ../../edge-impulse-sdk/tensorflow/lite/kernels/internal/: quantization_util.cpp
  group micro
    ../../edge-impulse-sdk/tensorflow/lite/micro/: all_ops_resolver.cpp memory_helpers.cpp micro_allocator.cpp micro_error_reporter.cpp micro_interpreter.cpp micro_profiler.cpp micro_string.cpp micro_time.cpp micro_utils.cpp recording_micro_allocator.cpp recording_simple_memory_allocator.cpp schema_utils.cpp simple_memory_allocator.cpp system_setup.cpp test_helpers.cpp
  group micro-memory_planner
    ../../edge-impulse-sdk/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cpp linear_memory_planner.cpp
  group micro-kernels
    ../../edge-impulse-sdk/tensorflow/lite/micro/kernels/: activations.cpp add.cpp add_n.cpp arg_min_max.cpp batch_to_space_nd.cpp cast.cpp ceil.cpp circular_buffer.cpp comparisons.cpp concatenation.cpp conv.cpp conv_common.cpp depthwise_conv.cpp depthwise_conv_common.cpp dequantize.cpp div.cpp elementwise.cpp elu.cpp ethosu.cpp exp.cpp expand_dims.cpp fill.cpp floor.cpp fully_connected.cpp fully_connected_common.cpp hard_swish.cpp kernel_runner.cpp kernel_util_micro.cpp l2_pool_2d.cpp l2norm.cpp leaky_relu.cpp logical.cpp logistic.cpp maximum_minimum.cpp mli_slicers.cpp mul.cpp neg.cpp pack.cpp pad.cpp pooling.cpp prelu.cpp quantize.cpp quantize_common.cpp reduce.cpp reshape.cpp resize_nearest_neighbor.cpp round.cpp scratch_buf_mgr.cpp scratch_buffers.cpp shape.cpp softmax.cpp softmax_common.cpp space_to_batch_nd.cpp split.cpp split_v.cpp squeeze.cpp strided_slice.cpp sub.cpp svdf.cpp svdf_common.cpp tanh.cpp tflite_detection_postprocess.cpp transpose_conv.cpp unpack.cpp zeros_like.cpp
