# IAR project NonSecure.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 7
  ICCARM.CCDefines: SYSTEM_CORE_CLOCK=25000000
  ICCARM.IExtraOptions: --diag_suppress Pe550
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\tz_demo; ..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM55\non_secure; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM55\secure
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..
  OBJCOPY.OOCOutputFile: NonSecure.srec
  ILINK.IlinkOutputFile: NonSecure.out
  ILINK.IlinkIcfFile: M55M1_ns.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group CMSELib
    ../../CMSELib/: nsclib_iar.o
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c
  group Demos
    ../../tz_demo/: tz_demo.c
  group Driver
    ../../../../../Library/StdDriver/src/: gpio.c retarget.c
  group FreeRTOS
    ../../../../../ThirdParty/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM55/non_secure/: port.c portasm.s
  group User
    ../: main_ns.c
