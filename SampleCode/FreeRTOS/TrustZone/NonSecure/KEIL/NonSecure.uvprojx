# Keil uVision project NonSecure.uvprojx, settings and files
target NonSecure (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: NonSecure +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: TRUSTZONE_BUILD,TRUSTZONE_NONSECURE,SYSTEM_CORE_CLOCK=180000000
  c include: ..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55\non_secure;..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55\secure;..\..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\TrustZone;..\..\..\..\..\Library\StdDriver\inc;..\..\tz_demo
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\M55M1_ns.sct
  link misc: --predefine="-I..\.." --predefine="-I.."
  group User
    ../: main_ns.c
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c
  group CMSELib
    ../../CMSELib/: nsclib_keil.o
  group FreeRTOS
    ../../../../../ThirdParty/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM33/non_secure/: port.c portasm.c
  group Demos
    ../../tz_demo/: tz_demo.c
  group Driver
    ../../../../../Library/StdDriver/src/: retarget.c
