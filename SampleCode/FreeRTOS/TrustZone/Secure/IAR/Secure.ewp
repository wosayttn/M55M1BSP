# IAR project Secure.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 7
  ICCARM.CCDefines: __HXT=24000000UL; DEBUG_PORT=UART0; NVT_VECTOR_ON_FLASH
  ICCARM.IExtraOptions: --diag_suppress Pe550
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM55\secure; ..\..\tz_demo; ..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\corstone300; ..\..; ..\..\..\..\..\Library\StdDriver\inc\scu
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..
  OBJCOPY.OOCOutputFile: Secure.srec
  postbuild: xcopy /Y Debug\Exe\nsclib_iar.o ..\..\CMSELib\
  ILINK.IlinkOutputFile: Secure.out
  ILINK.IlinkIcfFile: M55M1_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c pmc.c retarget.c sys.c uart.c
    ../../../../../Library/StdDriver/src/scu/: mpc_sie_drv.c
  group NSCFunctions
    ../../tz_demo/: nsc_functions.c
  group SecureContext
    ../../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM55/secure/: secure_context.c secure_context_port_asm.s
  group SecureHeap
    ../../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM55/secure/: secure_heap.c
  group SecureInit
    ../../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM55/secure/: secure_init.c
  group User
    ../: main_s.c
