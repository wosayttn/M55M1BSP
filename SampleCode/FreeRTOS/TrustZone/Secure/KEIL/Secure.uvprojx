# Keil uVision project Secure.uvprojx, settings and files
target Secure (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: Secure
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\release\@L.bin"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __HXT=24000000UL, DEBUG_PORT=UART0, NVT_VECTOR_ON_FLASH
  c include: ..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\..\Library\StdDriver\inc;..\..;..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55\secure
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Secure.scatter
  link misc: --import-cmse-lib-out ..\..\CMSELib\nsclib_keil.o
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c fmc.c
    ../../../../../Library/StdDriver/src/scu/: mpc_sie_drv.c
  group User
    ../../: partition_M55M1.h
    ../: main_s.c
  group NSCFunctions
    ../../tz_demo/: nsc_functions.c
  group SecureContext
    ../../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM55/secure/: secure_context.c secure_context_port.c
  group SecureInit
    ../../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM55/secure/: secure_init.c
  group SecureHeap
    ../../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM55/secure/: secure_heap.c
