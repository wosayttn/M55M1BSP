# IAR project TicklessIdle.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 7
  ICCARM.CCDefines: SYSTEM_CORE_CLOCK=180000000
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM55_NTZ\non_secure; ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: SYSTEM_CORE_CLOCK=25000000
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: TicklessIdle.bin
  ILINK.IlinkOutputFile: TicklessIdle.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM55_NTZ/non_secure/: port.c portasm.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c pmc.c retarget.c rtc.c sys.c uart.c
  group User
    ../: main.c ParTest.c PortSuppressTicksAndSleep.c
