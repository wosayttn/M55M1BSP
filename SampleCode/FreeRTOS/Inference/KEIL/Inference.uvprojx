# Keil uVision project Inference.uvprojx, settings and files
target Release (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: Inference
  AfterMake: fromelf --bin --output=mps3_image\ "$L@L.axf"
  AfterMake: fromelf --text -c "$L@L.axf" --output=outfile.lst
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: SYSTEM_CORE_CLOCK=180000000, TF_LITE_STATIC_MEMORY
  c include: ..\arm_profiler\include;..\inference_process\include;..\ethosu_log\include;..\models;..\..\..\..\ThirdParty\tflite_micro;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\..\..\..\ThirdParty\FreeRTOS\Lib;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55_NTZ\non_secure
  memory RVCT4: ROM 0x11000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scatter
  group User
    ../: main.cpp
    ../inference_process/src/: inference_process.cpp
    ../arm_profiler/src/: arm_profiler.cpp
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Dirver
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Lib
    C:/NuMicro Projects/M55M1_PRJ/bsp/Library/CMSIS/Lib/KEIL/: cmsis_nn.lib
    ../../../../ThirdParty/FreeRTOS/Lib/: FreeRTOS.lib
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.lib
