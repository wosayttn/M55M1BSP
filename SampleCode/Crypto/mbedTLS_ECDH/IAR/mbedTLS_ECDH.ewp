# IAR project mbedTLS_ECDH.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1 series Nuvoton M55M1 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; ARM_MATH_DSP; MBEDTLS_CONFIG_FILE
  ICCARM.CCDiagSuppress: Pa082, Pe188
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\CryptoAccelerator; ..\..\..\..\ThirdParty\mbedtls\include; ..\..\..\..\ThirdParty\mbedtls\library; ..\..\..\..\ThirdParty\mbedtls\tests\include\mbedtls; ..\..\..\..\ThirdParty\mbedtls\tests\include; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mbedTLS_ECDH.bin
  ILINK.IlinkOutputFile: mbedTLS_ECDH.out
  ILINK.IlinkIcfFile: C:\WORK\IC Verification\Full Design Package\M55M1_BSP\yy\bsp\SampleCode\Crypto\mbedTLS_ECDH\IAR\M55M1.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Library\CryptoAccelerator\lib\mbedcrypto.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group mbedtls
    ../../../../ThirdParty/mbedtls/tests/src/: helpers.c psa_crypto_helpers.c random.c
  group User
    ../: test_suite_ecdh.c
