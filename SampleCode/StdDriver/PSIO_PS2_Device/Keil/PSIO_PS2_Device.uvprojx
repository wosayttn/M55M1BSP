# Keil uVision project PSIO_PS2_Device.uvprojx, settings and files
target PSIO_PS2_Device (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: PSIO_PS2_Device
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: DEBUG_PORT=UART0, STDIN_ECHO=1
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\StdDriver\inc;..\..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scatter
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c
  group User
    ../: main.c PS2_Device_driver.c
target PSIO_PS2_Device_SRAM (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: PSIO_PS2_Device_SRAM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: DEBUG_PORT=UART0, __PLDM_EMU__
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\StdDriver\inc;..\..\common\inc;..\
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1-SRAM.scatter
