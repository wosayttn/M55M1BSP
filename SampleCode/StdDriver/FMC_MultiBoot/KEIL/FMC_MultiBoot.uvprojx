# Keil uVision project FMC_MultiBoot.uvprojx, settings and files
target FMC_MultiBoot_0x100000 (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: FMC_MultiBoot_0x100000
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\FMC_MultiBoot_APROM.scatter
  link misc: --predefine="-DVECMAP_BASE=0x100000"
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c fmc.c
  group User
    ../: main.c
target FMC_MultiBoot_0x160000 (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: FMC_MultiBoot_0x160000
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\FMC_MultiBoot_APROM.scatter
  link misc: --predefine="-DVECMAP_BASE=0x160000"
target FMC_MultiBoot_0x1C0000 (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: FMC_MultiBoot_0x1C0000
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\FMC_MultiBoot_APROM.scatter
  link misc: --predefine="-DVECMAP_BASE=0x1C0000"
target FMC_MultiBoot_0x220000 (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: FMC_MultiBoot_0x220000
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\FMC_MultiBoot_APROM.scatter
  link misc: --predefine="-DVECMAP_BASE=0x220000"
target FMC_MultiBoot_0x280000 (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: FMC_MultiBoot_0x280000
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\FMC_MultiBoot_APROM.scatter
  link misc: --predefine="-DVECMAP_BASE=0x280000"
target FMC_MultiBoot_LDROM (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: FMC_MultiBoot_LDROM
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\FMC_MultiBoot_LDROM.scatter
