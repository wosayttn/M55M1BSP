<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SPIM_DMM_RunHFlashCode.ewp</path>
    </project>
    <batchBuild />
</workspace>
