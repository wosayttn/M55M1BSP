# IAR project NPU_Conv.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: M55M1 series Nuvoton M55M1 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NVT_VECTOR_ON_FLASH
  ICCARM.CCIncludePath2: ..\..\..\..\Library\StdDriver\src\npu; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\StdDriver\inc\npu; ..\..\..\..\Library\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: NPU_Conv.srec
  ILINK.IlinkOutputFile: NPU_Conv.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkExtraOptions: --redirect __write=__write_own
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group User
    ../: command_stream.cpp main.cpp
