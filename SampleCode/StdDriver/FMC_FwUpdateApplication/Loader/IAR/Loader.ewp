# IAR project Loader.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1 series Nuvoton M55M1 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\common\inc; ..\..\..\..\..\Library\NuMaker\Commu
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Loader.bin
  ILINK.IlinkOutputFile: Loader.out
  ILINK.IlinkIcfFile: Loader.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c crc.c fmc.c retarget.c sys.c timer.c uart.c
    ../../../../../Library/NuMaker/Commu/: xmodem.c
  group User
    ../: main.c
