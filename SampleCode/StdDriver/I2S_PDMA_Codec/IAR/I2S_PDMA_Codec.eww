<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\I2S_PDMA_Codec.ewp</path>
    </project>
    <batchBuild />
</workspace>
