# IAR project HSUSBD_Audio10_Headset.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 7
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: HSUSBD_Audio20_Headset.bin
  ILINK.IlinkOutputFile: HSUSBD_Audio20_Headset.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkExtraOptions: --redirect __write=__write_own
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: sys.c clk.c gpio.c retarget.c uart.c i2c.c i2s.c timer.c pdma.c hsusbd.c
  group User
    ../: main.c descriptors.c config_pdma.c audio_codec.c usbd_audio.c hid.c
