# IAR project SPIM_HYPER_ExeInHRAM.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1 series Nuvoton M55M1 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPIM_HYPER_ExeInHRAM.hex
  ILINK.IlinkOutputFile: SPIM_HYPER_ExeInHRAM.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../: startup_M55M1.c
    ../../../../Library/Device/Nuvoton/M55M1/Source/: system_M55M1.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c otfc.c retarget.c spim_hyper.c sys.c uart.c
  group User
    ../: hyperram_code.c main.c spim_code.c
