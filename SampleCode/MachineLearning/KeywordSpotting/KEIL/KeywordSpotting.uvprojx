# Keil uVision project KeywordSpotting.uvprojx, settings and files
target M55M1 (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: KeywordSpotting
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\release\@L.bin"
  AfterMake: ..\..\..\binToDat.bat ".\Objects\@L.axf"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: DEBUG_PORT=UART0, NVT_VECTOR_ON_FLASH, NVT_DCACHE_ON, TF_LITE_STATIC_MEMORY, ARM_MATH_DSP, ARM_NPU, ACTIVATION_BUF_SZ=0x00100000, MODEL_DS_CNN
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\..\..\..\ThirdParty\openmv\omv\imlib;..\..\..\..\ThirdParty\openmv\omv\alloc;..\..\..\..\ThirdParty\openmv\omv\common;..\..\..\..\ThirdParty\openmv\omv\Lib;..\..\..\..\ThirdParty\tflite_micro;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\use_case\kws\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include;..\Device\include;..\Model\include;..\NPU\include;..\Pattern\include;..\ProfilerCounter\include
  memory RVCT4: ROM 0x11000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x31000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\M55M1.scatter
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: uart.c retarget.c clk.c sys.c gpio.c dmic.c lppdma.c
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Application
    ../: BoardInit.cpp main.cpp
  group Lib
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.lib
    C:/NuMicro Projects/M55M1_PRJ/bsp/Library/CMSIS/Lib/KEIL/: cmsis_dsp.lib cmsis_nn.lib
  group Model
    ../Model/: KwsModel.cpp Labels.cpp ds_cnn_m_quantized_vela_H256.tflite.cpp kws_micronet_m_vela_H256.tflite.cpp
  group Pattern
    ../Pattern/: down.cpp InputFiles.cpp right_left_up.cpp yes.cpp yes_no_go_stop.cpp
  group ArmMLApi
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/application/api/common/source/: Model.cc TensorFlowLiteMicro.cc Classifier.cc Mfcc.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/math/: PlatformMath.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/profiler/: Profiler.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/application/api/use_case/kws/src/: KwsProcessing.cc
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group ProfilerCounter
    ../ProfilerCounter/: pmu_counter.c
  group Device
    ../Device/DMICRecord/: DMICRecord.c
