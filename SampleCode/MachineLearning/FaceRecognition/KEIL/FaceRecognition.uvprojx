# Keil uVision project FaceRecognition.uvprojx, settings and files
target M55M1 (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: FaceRecognition
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output=release
  AfterMake: ..\..\..\binToDat.bat ".\Objects\@L.axf"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: DEBUG_PORT=UART0, NVT_VECTOR_ON_FLASH, NVT_DCACHE_ON, TF_LITE_STATIC_MEMORY, ARM_MATH_DSP, ARM_NPU, ACTIVATION_BUF_SZ=0x00080000
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\..\..\..\ThirdParty\openmv\omv\imlib;..\..\..\..\ThirdParty\openmv\omv\alloc;..\..\..\..\ThirdParty\openmv\omv\common;..\..\..\..\ThirdParty\openmv\omv\Lib;..\..\..\..\ThirdParty\tflite_micro;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include;..\Device\include;..\Model\include;..\NPU\include;..\Pattern\include;..\ProfilerCounter\include
  memory RVCT4: ROM 0x11000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x31000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\M55M1.scatter
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: uart.c retarget.c ccap.c clk.c sys.c gpio.c spim_hyper.c
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Application
    ../: BoardInit.cpp main.cpp Recognizer.cpp FaceRecognProcessing.cpp FaceDetect.c
  group Lib
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.lib
    C:/NuMicro Projects/M55M1_PRJ/bsp/Library/CMSIS/Lib/KEIL/: cmsis_dsp.lib cmsis_nn.lib
    ../../../../ThirdParty/openmv/omv/Lib/: omv.lib
  group Model
    ../Model/: Labels.cpp mobilenet_fr_int8_vela_H256.tflite.cpp MobileNetModel.cpp
  group Pattern
    ../Pattern/: InputFiles.cpp test1_qvga.cpp test2_qvga.cpp test3_qvga.cpp test4_qvga.cpp test5_qvga.cpp test6_qvga.cpp test7_qvga.cpp test8_qvga.cpp test9_qvga.cpp test10_qvga.cpp
  group ArmMLApi
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/application/api/common/source/: Model.cc TensorFlowLiteMicro.cc Classifier.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/math/: PlatformMath.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/profiler/: Profiler.cc
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group ProfilerCounter
    ../ProfilerCounter/: pmu_counter.c
  group Device
    ../Device/HyperFlash/: hyperflash_code.c
