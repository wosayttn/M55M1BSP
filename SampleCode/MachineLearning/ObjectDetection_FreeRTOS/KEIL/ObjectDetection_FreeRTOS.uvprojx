# Keil uVision project ObjectDetection_FreeRTOS.uvprojx, settings and files
target M55M1 (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: ObjectDetection_FreeRTOS
  AfterMake: fromelf --bin --output=image\ "$L@L.axf"
  AfterMake: fromelf --text -c "$L@L.axf" --output=outfile.lst
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: TF_LITE_STATIC_MEMORY, ARM_MATH_DSP, ARM_NPU, CPU_PROFILE_ENABLED, ACTIVATION_BUF_SZ=0x00140000, __PROFILE, USE_CCAP
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\application\main\include;..\application\tflu\include;..\use_case\include;..\generated\include;..\log\include;..\math\include;..\hal\include;..\hal\components\lcd\include;..\hal\components\lcd;..\hal\components\stdout\include;..\hal\components\platform_pmu\include;..\hal\platform\m55m1\include;..\hal\platform\m55m1;..\hal\components\npu\include;..\hal\components\img_sensor\include;..\hal\components\img_sensor\sensor;..\profiler\include;..\..\..\..\ThirdParty\openmv\omv\imlib;..\..\..\..\ThirdParty\openmv\omv\alloc;..\..\..\..\ThirdParty\openmv\omv\common;..\..\..\..\ThirdParty\openmv\omv\Lib;..\..\..\..\ThirdParty\tflite_micro;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Lib;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55_NTZ\non_secure
  memory RVCT4: ROM 0x11000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x31000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\M55M1.scatter
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: uart.c retarget.c ccap.c clk.c spim.c sys.c gpio.c
  group application-main
    ../application/main/: Main.cc UseCaseCommonUtils.cc ImageUtils.cc Detector.cc
  group Lib
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.lib
    C:/NuMicro Projects/M55M1_PRJ/bsp/Library/CMSIS/Lib/KEIL/: cmsis_dsp.lib cmsis_nn.lib
    ../../../../ThirdParty/openmv/omv/Lib/: omv.lib
    ../../../../ThirdParty/FreeRTOS/Lib/: FreeRTOS.lib
  group use_case
    ../use_case/: MainLoop.cc UseCaseHandler.cc DetectorPostProcessing.cc YoloFastestModel.cc InferenceProcess.cc
  group hal
    ../hal/: hal.c hal_timer.c
  group hal-components-lcd
    ../hal/components/lcd/: lcd_img.c
  group hal-components-stdout
    ../hal/components/stdout/: user_input.c
  group hal-components-lcd-glcd_stubs
    ../hal/components/lcd/glcd_stubs/: glcd_stubs.c
  group hal-components-npu
    ../hal/components/npu/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group hal-components-img_sensor
    ../hal/components/img_sensor/: img_sensor.c
  group hal-components-img_sensor-sensor
    ../hal/components/img_sensor/sensor/: sensor_PLDM.c
  group hal-platform-m55m1
    ../hal/platform/m55m1/: platform_drivers.c timer_m55m1_platform.c hyperflash_code.c hyperram_code.c
  group application-tflu
    ../application/tflu/: Model.cc TensorFlowLiteMicro.cc
  group profiler
    ../profiler/: Profiler.cc
  group generated
    ../generated/: InputFiles.cc Labels.cc car.cc dinner.cc yolo-fastest_int8_vela_H256.tflite.cc
  group ethosu
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group math
    ../math/: PlatformMath.cc
