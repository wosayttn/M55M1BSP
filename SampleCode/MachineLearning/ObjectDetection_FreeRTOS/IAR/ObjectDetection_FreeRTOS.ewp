# IAR project ObjectDetection_FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 7
  ICCARM.CCDefines: TF_LITE_STATIC_MEMORY; ARM_NPU; CPU_PROFILE_ENABLED; ACTIVATION_BUF_SZ=0x00140000; __PROFILE; USE_CCAP
  ICCARM.IExtraOptions: --diag_suppress Pe550
  ICCARM.CCIncludePath2: ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\CMSIS\DSP\Include; ..\..\..\..\ThirdParty\tflite_micro; ..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include; ..\application\main\include; ..\application\tflu\include; ..\use_case\include; ..\generated\include; ..\log\include; ..\math\include; ..\hal\include; ..\hal\components\lcd\include; ..\hal\components\stdout\include; ..\hal\components\platform_pmu\include; ..\profiler\include; ..\hal\components\lcd; ..\hal\platform\m55m1\include; ..\hal\components\cmsis_device\include; ..\hal\components\npu\include; ..\..\..\..\Library\StdDriver\inc\npu; ..\hal\platform\m55m1; ..\hal\components\img_sensor\include; ..\math\include; ..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\..\..\ThirdParty\FreeRTOS\Lib; ..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55_NTZ\non_secure
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FaceRecognition.srec
  ILINK.IlinkOutputFile: ObjectDetection.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application-main
    ../application/main/: Detector.cc ImageUtils.cc Main.cc UseCaseCommonUtils.cc
  group application-tflu
    ../application/tflu/: Model.cc TensorFlowLiteMicro.cc
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: ccap.c clk.c gpio.c retarget.c spim.c sys.c uart.c
  group ethosu
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group generated
    ../generated/: car.cc dinner.cc InputFiles.cc Labels.cc yolo-fastest_int8_vela_H256.tflite.cc
  group hal
    ../hal/: hal.c hal_timer.c
  group hal-components-img_sensor
    ../hal/components/img_sensor/: img_sensor.c
  group hal-components-img_sensor-sensor
    ../hal/components/img_sensor/sensor/: sensor_PLDM.c
  group hal-components-lcd
    ../hal/components/lcd/: lcd_img.c
  group hal-components-lcd-glcd_stubs
    ../hal/components/lcd/glcd_stubs/: glcd_stubs.c
  group hal-components-npu
    ../hal/components/npu/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group hal-components-stdout
    ../hal/components/stdout/: user_input.c
  group hal-platfrom-m55m1
    ../hal/platform/m55m1/: hyperflash_code.c hyperram_code.c platform_drivers.c timer_m55m1_platform.c
  group Lib
    ../../../../Library/CMSIS/Lib/IAR/: CMSIS_DSP.a CMSIS_NN.a
    ../../../../ThirdParty/FreeRTOS/Lib/: FreeRTOS.a
    ../../../../ThirdParty/openmv/omv/Lib/: omv.a
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.a
  group math
    ../math/: PlatformMath.cc
  group profiler
    ../profiler/: Profiler.cc
  group use_case
    ../use_case/: DetectorPostProcessing.cc InferenceProcess.cc MainLoop.cc UseCaseHandler.cc YoloFastestModel.cc
