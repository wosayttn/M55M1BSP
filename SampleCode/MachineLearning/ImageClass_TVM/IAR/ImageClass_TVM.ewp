# IAR project ImageClass_TVM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 7
  ICCARM.IExtraOptions: --diag_suppress Pe550; --diag_suppress Pe1097
  ICCARM.CCIncludePath2: ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\CMSIS\DSP\Include; ..\..\..\..\Library\CMSIS\NN\Include; ..; ..\codegen\host\include; ..\runtime\include; ..\microtvm\ethosu\include; ..\..\..\..\Library\StdDriver\inc\npu
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FaceRecognition.srec
  ILINK.IlinkOutputFile: ImageClass_TVM.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group codegen
    ../codegen/host/src/: default_lib0.c default_lib1.c default_lib2.c default_lib3.c
  group Driver
    ../../../../Library/StdDriver/src/: ccap.c clk.c gpio.c retarget.c spim.c sys.c uart.c
  group ethosu
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Lib
    ../../../../Library/CMSIS/Lib/IAR/: CMSIS_DSP.a CMSIS_NN.a
  group microtvm
    ../microtvm/ethosu/src/: tvm_ethosu_runtime.c
  group runtime
    ../runtime/src/runtime/crt/common/: crt_backend_api.c crt_runtime_api.c func_registry.c ndarray.c
    ../runtime/src/runtime/crt/memory/: stack_allocator.c
  group User
    ../: main.c
