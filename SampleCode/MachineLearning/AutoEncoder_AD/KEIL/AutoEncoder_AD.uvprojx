# Keil uVision project AutoEncoder_AD.uvprojx, settings and files
target M55M1 (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: AutoEncoder_AD
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: ARM_MATH_DSP,ARM_MATH_HELIUM,TF_LITE_STATIC_MEMORY,CMSIS_NN, ARM_NPU
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\CMSIS\NN\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\ThirdParty\tflite_micro;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include;..\NN\CNN\;..\NNClassify\;..\NPU\include;..\Generated\;..\NN\;..\
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\M55M1.scatter
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Generated
    ../Generated/: ad_imu_model_quant_vela.tflite.cc
  group Library
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.lib
    C:/WORK/IC Verification/Full Design Package/M55M1_BSP/yy/bsp/Library/CMSIS/Lib/KEIL/: cmsis_dsp.lib cmsis_nn.lib
  group Classify
    ../NNClassify/: MainClassify.cc
  group NN
    ../NN/: Model.cc
    ../NN/CNN/: CnnModel.cc
  group NPU
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Driver
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c sys.c gpio.c ebi.c epwm.c pdma.c i2c.c timer.c lpi2c.c
    ../NPU/: ethosu_npu_init.c ethosu_profiler.c ethosu_cpu_cache.c
  group User
    ../: main.cpp MPU6500.c
