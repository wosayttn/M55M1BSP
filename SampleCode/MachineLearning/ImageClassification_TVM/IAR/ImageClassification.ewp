# IAR project ImageClassification.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: M55M1 series Nuvoton M55M1 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NVT_VECTOR_ON_FLASH; NVT_DCACHE_ON; ARM_NPU; USE_CCAP
  ICCARM.CCDiagSuppress: Pe1097, Pe550, Pe188, Pe546, Pe301
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\CMSIS\DSP\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\StdDriver\inc\npu; ..\Device\include; ..\NPU\include; ..\codegen_H256\host\include; ..\runtime\include; ..\microtvm\ethosu\include; ..\..\..\..\Library\CMSIS\NN\Include; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: FaceRecognition.srec
  ILINK.IlinkOutputFile: ImageClassification.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group codegen
    ../codegen_H256/host/src/: default_lib0.c default_lib1.c default_lib2.c default_lib3.c
  group Device
    ../Device/HyperFlash/: hyperflash_code.c
  group Driver
    ../../../../Library/StdDriver/src/: ccap.c clk.c gpio.c retarget.c spim_hyper.c sys.c uart.c
  group ethosu
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Lib
    ../../../../Library/CMSIS/Lib/IAR/: CMSIS_DSP.a CMSIS_NN.a
  group microtvm
    ../microtvm/ethosu/src/: tvm_ethosu_runtime.c
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c
  group runtime
    ../runtime/src/runtime/crt/common/: crt_backend_api.c crt_runtime_api.c func_registry.c ndarray.c
    ../runtime/src/runtime/crt/memory/: stack_allocator.c
  group User
    ../: BoardInit.c main.c
