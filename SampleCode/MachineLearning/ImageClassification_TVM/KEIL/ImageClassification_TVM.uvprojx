# Keil uVision project ImageClassification_TVM.uvprojx, settings and files
target M55M1 (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: ImageClass_TVM
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output=release
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: NVT_VECTOR_ON_FLASH, ARM_NPU, NVT_DCACHE_ON
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\codegen_H256\host\include;..\runtime\include;..\microtvm\ethosu\include;..\..\..\..\Library\CMSIS\NN\Include;..\;..\NPU\include;..\Device\include;..\..\ImageClassification_TVM
  memory RVCT4: ROM 0x11000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x31000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\M55M1.scatter
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: uart.c retarget.c ccap.c clk.c spim.c sys.c gpio.c spim_hyper.c
  group Lib
    ../../../../Library/CMSIS/Lib/KEIL/: cmsis_dsp.lib cmsis_nn.lib
  group ethosu
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group User
    ../: main.c BoardInit.c mpu_config_M55M1.h
  group runtime
    ../runtime/src/runtime/crt/common/: crt_backend_api.c crt_runtime_api.c func_registry.c ndarray.c
    ../runtime/src/runtime/crt/memory/: stack_allocator.c
  group codegen
    ../codegen_H256/host/src/: default_lib0.c default_lib1.c default_lib2.c default_lib3.c
  group microtvm
    ../microtvm/ethosu/src/: tvm_ethosu_runtime.c
  group Device
    ../Device/HyperFlash/: hyperflash_code.c
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c
