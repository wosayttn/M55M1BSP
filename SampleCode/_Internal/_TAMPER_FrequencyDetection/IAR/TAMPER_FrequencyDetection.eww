<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TAMPER_FrequencyDetection.ewp</path>
    </project>
    <batchBuild />
</workspace>
