# IAR project Inference.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: M55M1 series Nuvoton M55M1 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 7
  ICCARM.CCDefines: TF_LITE_STATIC_MEMORY; SYSTEM_CORE_CLOCK=18000000
  ICCARM.CCDiagSuppress: Pe997, Pe550
  ICCARM.CCIncludePath2: ..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\arm_profiler\include; ..\inference_process\include; ..\..\..\..\ThirdParty\tflite_micro; ..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M55M1\Include; ..\..\..\..\Library\StdDriver\inc; ..\ethosu_log\include; ..\..\..\..\ThirdParty\FreeRTOS\Lib; ..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM55_NTZ\non_secure; ..\models; ..\..\..\..\Library\StdDriver\inc\npu
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: Inference.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Lib
    ../../../../Library/CMSIS/Lib/IAR/: CMSIS_NN.a
    ../../../../ThirdParty/FreeRTOS/Lib/: FreeRTOS.a
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.a
  group User
    ../arm_profiler/src/: arm_profiler.cpp
    ../inference_process/src/: inference_process.cpp
    ../: main.cpp
