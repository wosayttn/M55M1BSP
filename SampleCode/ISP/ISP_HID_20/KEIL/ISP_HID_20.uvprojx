# Keil uVision project ISP_HID_20.uvprojx, settings and files
target ISP_HID_20 (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: ISP_HID_20
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: DEBUG_PORT=UART0
  c include: ..;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1-LDROM.scatter
  group CMSIS
    ../../: ISP_startup_M55M1.c ISP_system_M55M1.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c
  group User
    ../: main.c descriptors.c fmc_user.c hid_transfer.c isp_user.c targetdev.c hsusbd_user.c
