# Keil uVision project cunit.uvprojx, settings and files
target GDMA (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: GDMA
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: DEBUG_PORT=UART0, STDIN_ECHO=1
  c include: ..\..\..\Library\CMSIS\Core\Include;..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\Library\StdDriver\inc;..\..\common\inc;..\..\..\Library\StdDriver\inc\gdma
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\M55M1.scatter
  group CMSIS
    ../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c pdma.c gpio.c pmc.c
    ../../common/: CUnitTestM55.lib
  group User
    ../: main.c gdma_cunit.c gdma_cunit.h
  group DMA350
    ../../../Library/StdDriver/src/gdma/: dma350_address_remap_template.c dma350_ch_drv.c dma350_drv.c dma350_lib.c
target GDMA_SRAM (6180000::V6.18::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: GDMA_SRAM
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\M55M1-SRAM.scatter
