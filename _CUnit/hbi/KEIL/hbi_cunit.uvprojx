# Keil uVision project hbi_cunit.uvprojx, settings and files
target hbi_cunit (6180000::V6.18::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: hbi_cunit
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: HBI_ENABLE=2
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\m460\Include;..\..\..\Library\StdDriver\inc;..\..\common\inc
  asm define: Stack_Size=0x800, Heap_Size=0x800
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_m460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
    ../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group User
    ../: main.c hbi_cunit.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c gpio.c sys.c clk.c uart.c hbi.c
    ../../common/: CUnitTestM4.lib
